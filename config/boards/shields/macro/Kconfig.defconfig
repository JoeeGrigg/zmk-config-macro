## config/boards/shields/macro/Kconfig.defconfig
```kconfig
if SHIELD_MACRO

config ZMK_BLE
    default y

config ZMK_KEYBOARD_NAME
    default "macro"

endif
```
